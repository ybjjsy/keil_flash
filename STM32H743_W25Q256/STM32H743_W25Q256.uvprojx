# Keil uVision project STM32H743_W25Q256.uvprojx, settings and files
target STM32H743_W25Q256 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743_W25Q256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: W25Q256FV, STM32H743xx
  c misc: --diag_suppress=66
  c include: ..\..\test;.\devices\CORE;..\STM32H743_W25Q256;.\devices\SYSTEM\delay;.\devices\SYSTEM\sys;.\devices\HARDWARE\QSPI;.\devices\HARDWARE\W25QXX;.\devices\STM32H7xx_HAL_Driver\Inc;.\devices\SYSTEM\usart;.\devices\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group HARDWARE
    ./devices/HARDWARE/QSPI/: qspi.c
    ./devices/HARDWARE/W25QXX/: w25qxx.c
    ./devices/HARDWARE/LED/: led.c
  group SYSTEM
    ./devices/SYSTEM/delay/: delay.c
    ./devices/SYSTEM/sys/: sys.c
    ./devices/SYSTEM/usart/: usart.c
software components: CMSIS:CORE 5.1.1
